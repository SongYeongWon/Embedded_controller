# Keil uVision project Stepper Motor.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tutorial_EXTI_SysTick +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: Stepper Motor.c
  group HAL
    ../../lib/: ecGPIO.c ecGPIO.h ecRCC.c ecRCC.h EC_API.cpp EC_API.h ecPWM.c ecPWM.h ecTIM.c ecTIM.h ecUART.c ecUART.h
    ./: ecSysTick.c ecSysTick.h ecEXTI.c ecEXTI.h ecStepper.c ecStepper.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
